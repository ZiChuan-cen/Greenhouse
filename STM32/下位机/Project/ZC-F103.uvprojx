# Keil uVision project ZC-F103.uvprojx, settings and files
target 下位机 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: smart-plant
  c flags: Optim=2 OneElfS=1 uC99=1 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\User\Usart;..\User\delay;..\User\sys;..\Device\BMP180;..\Device\BH1750;..\Device\OLED;..\Device\DHT11;..\Device\SoilHum;..\Device\DS18B20;..\Device\CO2;..\Device\ZigBee
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Device
    ../Device/BMP180/: BMP180.c myiic.c
    ../Device/BH1750/: BH1750.c
    ../Device/DHT11/: dht11.c
    ../Device/SoilHum/: soil_hum.c
    ../Device/DS18B20/: ds18b20.c
    ../Device/ZigBee/: Zigbee.c
    ../Device/CO2/: Jw01.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c
    ../User/delay/: delay.c
    ../User/Usart/: bsp_usart.c
    ../User/sys/: sys.c
  group DOC
    ../DOC/: 必读文档.txt
